## sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_ARDUINO_VARIANT="esp32c6"
CONFIG_AUTOSTART_ARDUINO=y
```
